	ORG 0000H
	LJMP START
	ORG 0030H
START:
	MOV R0,#0
	MOV R1,#0
MAIN:
	MOV A,R0
	MOV DPTR,#TABLEC
	MOVC A,@A+DPTR
	MOV P3,A
	MOV A,R0
	MOV DPTR,#TABLER
	MOVC A,@A+DPTR
	MOV P0,A
	LCALL DELAY100US
	INC R0
	CJNE R0,#8,MAIN
	CJNE R0,#10,START
DELAY100US:
	PUSH 30H
	MOV 30H,#41
NEXT:
	DJNZ	30H,NEXT
	POP		30H
	RET
TABLER:
	DB 	0xFF,0XFF,0X00,0X00,0XFC,0XFC,0xFF,0XFF ;行控制形状,低电平有效
TABLEC:
	DB 01H,02H,04H,08H,10H,20H,40H,80H			;列扫描，C7是高
END
