# Keil uVision project LED1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../51单片机工程模板/: main.c reg52.h
